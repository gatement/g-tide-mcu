# Keil uVision project Project.uvprojx, settings and files
target GoKit (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gokit +hex
  AfterMake: fromelf --bin .\output\gokit.axf  --output .\output\gokit.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Lib\inc;..\Lib\cmsis;..\user;..\Lib;..\User\Hal_Driver;..\User\Buz_Logic;..\User\Hal_Driver\GPIO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ../Lib/startup/arm/: startup_stm32f10x_md.s
  group lib
    ../Lib/cmsis/: core_cm3.c
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
    ../User/: delay.c
  group driver
    ../User/Hal_Driver/: hal_uart.c hal_temp_hum.c hal_infrared.c hal_motor.c hal_rgb_led.c hal_key.c
    ../User/Hal_Driver/GPIO/: sa_gpio.c
  group buz_logic
    ../User/Buz_Logic/: uart.c key.c infrared.c buz_protocol.c gen_protocol.c
